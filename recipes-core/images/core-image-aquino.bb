inherit core-image

CORE_IMAGE_EXTRA_INSTALL += "bluez5 iptables wpa-supplicant rpi-gpio networkmanager nano"

